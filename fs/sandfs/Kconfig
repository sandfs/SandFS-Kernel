## fs/sandfs/Kconfig
```kconfig
config SANDFS
	tristate "Sandfs sandboxing file system (EXPERIMENTAL)"
	help
	  Sandfs is a sandboxing file system.
```
